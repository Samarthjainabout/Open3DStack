
VERSION 5.8 ;

SITE CoreSite_T5
        CLASS CORE ;
        SYMMETRY Y ;
        SIZE 4.0 BY 20.0 ;
END CoreSite_T5

SITE DoubleHeightCoreSite_T5
        CLASS CORE ;
        SYMMETRY X Y ;
        SIZE 4.0 BY 40.0 ;
END DoubleHeightCoreSite_T5
